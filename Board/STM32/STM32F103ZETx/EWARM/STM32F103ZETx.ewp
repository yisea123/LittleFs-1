# IAR project STM32F103ZETx.ewp, settings and files
configuration STM32F103ZETx (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/Fal/Cfg; ../Middlewares/Fal/Port; ../Middlewares/LittleFs/Cfg; ../Middlewares/Lwmem/Cfg; ../Middlewares/Lwmem/Port; ../Middlewares/SUFD/Cfg; ../Middlewares/SystemView/Config; ../../../../Middlewares/Fal/Source; ../../../../Middlewares/LittleFs/Source; ../../../../Middlewares/Lwmem/Source; ../../../../Middlewares/Printf/Source; ../../../../Middlewares/SUFD/Source; ../../../../Middlewares/SystemView/SEGGER
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../Middlewares/SystemView/Config; ../../../../Middlewares/SystemView/SEGGER
  OBJCOPY.OOCOutputFile: STM32F103ZETx.hex
  ILINK.IlinkOutputFile: STM32F103ZETx.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Middlewares/Fal/Cfg
    ../Middlewares/Fal/Cfg/: fal_cfg.h
  group Middlewares/Fal/Port
    ../Middlewares/Fal/Port/: drv_flash.h drv_flash_f1.c fal_flash_sfud_port.c
  group Middlewares/Fal/Source
    ../../../../Middlewares/Fal/Source/: fal.c fal.h fal_def.h fal_flash.c fal_partition.c
  group Middlewares/Fal/Test
    ../Middlewares/Fal/Test/: fal_test.c
  group Middlewares/HardFault/Source
    ../../../../Middlewares/HardFault/Source/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group Middlewares/LittleFs/Cfg
    ../Middlewares/LittleFs/Cfg/: lfs_util.h
  group Middlewares/LittleFs/Port
    ../Middlewares/LittleFs/Port/: lfs_util.c
  group Middlewares/LittleFs/Source
    ../../../../Middlewares/LittleFs/Source/: lfs.c lfs.h
  group Middlewares/LittleFs/Test
    ../Middlewares/LittleFs/Test/: littlefs_test.c
  group Middlewares/Lwmem/Cfg
    ../Middlewares/Lwmem/Cfg/: lwmem_config.h lwmem_config_default.h
  group Middlewares/Lwmem/Port
    ../Middlewares/Lwmem/Port/: lwmem_init.c lwmem_sys.h lwmem_sys_nonos.c
  group Middlewares/Lwmem/Source
    ../../../../Middlewares/Lwmem/Source/: lwmem.c lwmem.h
  group Middlewares/Lwmem/Test
    ../Middlewares/Lwmem/Test/: lwmem_test.c
  group Middlewares/Printf/Source
    ../../../../Middlewares/Printf/Source/: printf.c printf.h
  group Middlewares/SUFD/Cfg
    ../Middlewares/SUFD/Cfg/: sfud_cfg.h
  group Middlewares/SUFD/Port
    ../Middlewares/SUFD/Port/: sfud_port.c
  group Middlewares/SUFD/Source
    ../../../../Middlewares/SUFD/Source/: sfud.c sfud.h sfud_def.h sfud_flash_def.h sfud_sfdp.c
  group Middlewares/SUFD/Test
    ../Middlewares/SUFD/Test/: sufd_test.c
  group Middlewares/SystemView/Config
    ../Middlewares/SystemView/Config/: Global.h SEGGER_RTT_Conf.h SEGGER_SYSVIEW_Conf.h
  group Middlewares/SystemView/Sample/NoOS/Config/Cortex-M
    ../Middlewares/SystemView/Sample/NoOS/Config/Cortex-M/: SEGGER_SYSVIEW_Config_NoOS.c
  group Middlewares/SystemView/SEGGER
    ../../../../Middlewares/SystemView/SEGGER/: SEGGER.h SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_ASM_ARMv7M.S SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_GCC.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_Syscalls_SES.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_Int.h
